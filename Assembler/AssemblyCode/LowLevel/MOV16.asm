; Set register XL to "11110000"
SET A, "1111"
SET B, "0000"
SHL
MOV_ALU_C_TO_AB A
SHL
MOV_ALU_C_TO_AB A
SHL
MOV_ALU_C_TO_AB A
SHL
MOV_ALU_C_TO_AB A
OR
MOV_ALU_OUT XL

; Set register XH to "00001111"
SET A, "0000"
SET B, "1111"
SHL
MOV_ALU_C_TO_AB A
SHL
MOV_ALU_C_TO_AB A
SHL
MOV_ALU_C_TO_AB A
SHL
MOV_ALU_C_TO_AB A
OR
MOV_ALU_OUT XH

; Perform the MOV16 operation
MOV16 SP, X
MOV16 J, SP
MOV16 Y, J
MOV16 Z, Y

HLT